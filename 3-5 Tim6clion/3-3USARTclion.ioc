# file: 3-3USARTclion.ioc
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Mcu.Family=STM32F1
Mcu.Name=STM32F103C(8-B)Tx
Mcu.Package=LQFP48
NVIC.PriorityGroup=NVIC_PRIORITYGROUP_4
PA0-WKUP.Signal=GPIO_Output
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
ProjectManager.HeapSize=0x200
ProjectManager.StackSize=0x400
ProjectManager.TargetToolchain=CMake
RCC.APB1Freq_Value=8000000
RCC.APB2Freq_Value=8000000
board=custom

// file: Core/Src/main.c
/* USER CODE BEGIN Header */
/**
  ******************************************************************************
  * @file           : main.c
  * @brief          : Main program body
  ******************************************************************************
  * @attention
  *
  * Copyright (c) 2025 STMicroelectronics.
  * All rights reserved.
  *
  * This software is licensed under terms that can be found in the LICENSE file
  * in the root directory of this software component.
  * If no LICENSE file comes with this software, it is provided AS-IS.
  *
  ******************************************************************************
  */
/* USER CODE END Header */
#include "main.h"

#include <stdio.h>
#include <string.h>

#include "led.h"
#include "key.h"
#include"exti.h"
#include "usart.h"
#include "Serial.h"
#include "stm32f1xx_hal.h"
#include "stm32f1xx_hal_usart.h"

void SystemClock_Config(void);
// static void MX_GPIO_Init(void);

int main(void)
{

  /* MCU Configuration--------------------------------------------------------*/

  /* Reset of all peripherals, Initializes the Flash interface and the Systick. */

  HAL_Init();
  SystemClock_Config();
  exti_init();
  HAL_NVIC_SetPriorityGrouping(NVIC_PRIORITYGROUP_2);  // ✅ 必须调用，设置优先级分组，全局
  /* USER CODE BEGIN Init */
  HAL_UART_Receive_IT(&g_usart_handle, g_rx_buffer, 10);
  /* USER CODE END Init */

  /* Configure the system clock */

  /* Initialize all configured peripherals */
  // MX_GPIO_Init();

  /* Infinite loop */
  /* USER CODE BEGIN WHILE */
  //key_init();
  led_init();
  uart_Init(115200);
  while (1)
  {
    /* USER CODE END WHILE */
    // Serial_send_byte('A');
    // HAL_Delay(500);

    if (g_uart_1_rx_flag == 1 && g_rx_buffer[0] != 0x00 )
    {
      HAL_UART_Transmit_IT(&g_usart_handle, g_rx_buffer, 1);  // 使用中断方式发送
      g_uart_1_rx_flag = 0;
    }

    // HAL_Delay(500); //单位是毫秒
  }
}

void SystemClock_Config(void)
{
  RCC_OscInitTypeDef RCC_OscInitStruct = {0};
  RCC_ClkInitTypeDef RCC_ClkInitStruct = {0};

  /** 初始化外部晶振 HSE 并使能 PLL */
  RCC_OscInitStruct.OscillatorType = RCC_OSCILLATORTYPE_HSE;
  RCC_OscInitStruct.HSEState = RCC_HSE_ON;
  RCC_OscInitStruct.HSEPredivValue = RCC_HSE_PREDIV_DIV1;
  RCC_OscInitStruct.PLL.PLLState = RCC_PLL_ON;
  RCC_OscInitStruct.PLL.PLLSource = RCC_PLLSOURCE_HSE;
  RCC_OscInitStruct.PLL.PLLMUL = RCC_PLL_MUL9; // 8MHz * 9 = 72MHz
  if (HAL_RCC_OscConfig(&RCC_OscInitStruct) != HAL_OK)
  {
    Error_Handler();
  }

  /** 初始化总线时钟 */
  RCC_ClkInitStruct.ClockType = RCC_CLOCKTYPE_HCLK | RCC_CLOCKTYPE_SYSCLK |
    RCC_CLOCKTYPE_PCLK1 | RCC_CLOCKTYPE_PCLK2;
  RCC_ClkInitStruct.SYSCLKSource = RCC_SYSCLKSOURCE_PLLCLK;
  RCC_ClkInitStruct.AHBCLKDivider = RCC_SYSCLK_DIV1;
  RCC_ClkInitStruct.APB1CLKDivider = RCC_HCLK_DIV2; // Max 36MHz
  RCC_ClkInitStruct.APB2CLKDivider = RCC_HCLK_DIV1;

  if (HAL_RCC_ClockConfig(&RCC_ClkInitStruct, FLASH_LATENCY_2) != HAL_OK)
  {
    Error_Handler();
  }
}

// static void MX_GPIO_Init(void)
// {
//   GPIO_InitTypeDef GPIO_InitStruct = {0};
//   /* USER CODE BEGIN MX_GPIO_Init_1 */
//
//   /* USER CODE END MX_GPIO_Init_1 */
//
//   /* GPIO Ports Clock Enable */
//   __HAL_RCC_GPIOA_CLK_ENABLE();
//
//   /*Configure GPIO pin Output Level */
//   HAL_GPIO_WritePin(GPIOA, GPIO_PIN_1, GPIO_PIN_RESET);
//
//   /*Configure GPIO pin : PA0 */
//   GPIO_InitStruct.Pin = GPIO_PIN_1;
//   GPIO_InitStruct.Mode = GPIO_MODE_OUTPUT_PP;
//   GPIO_InitStruct.Pull = GPIO_NOPULL;
//   GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_LOW;
//   HAL_GPIO_Init(GPIOA, &GPIO_InitStruct);
//
//   /* USER CODE BEGIN MX_GPIO_Init_2 */
//
//   /* USER CODE END MX_GPIO_Init_2 */
// }

void Error_Handler(void)
{
  __disable_irq();
  while (1)
  {
  }
}

int fputc(int ch, FILE *f)
{
  HAL_UART_Transmit(&g_usart_handle, (uint8_t *)&ch, 1, HAL_MAX_DELAY);
  return ch;
}
